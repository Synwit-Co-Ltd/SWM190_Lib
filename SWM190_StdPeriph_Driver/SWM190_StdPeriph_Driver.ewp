# IAR project SWM190_StdPeriph_Driver.ewp, settings and files
configuration SWM190 (ARM, debug)
  General.OGChipSelectEditMenu: SWM190xB Synwit SWM190xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: .\CSL\CMSIS\CoreSupport; .\CSL\CMSIS\DeviceSupport; .\CSL\SWM190_StdPeriph_Driver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _DLIB_FILE_DESCRIPTOR
  OBJCOPY.OOCOutputFile: SWM190_StdPeriph_Driver.srec
  ILINK.IlinkOutputFile: SWM190_StdPeriph_Driver.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ./app/: main.c
  group CSL\StdPD
    ./CSL/SWM190_StdPeriph_Driver/: SWM190_port.c SWM190_gpio.c SWM190_exti.c SWM190_timr.c SWM190_uart.c SWM190_adc.c SWM190_dma.c SWM190_i2c.c SWM190_pwm.c SWM190_spi.c SWM190_flash.c SWM190_rtc.c SWM190_wdt.c SWM190_cordic.c SWM190_div.c SWM190_cache.c SWM190_sleep.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM190.c
    ./CSL/CMSIS/DeviceSupport/startup/iar/: startup_SWM190.s
