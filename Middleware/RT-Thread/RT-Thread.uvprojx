# Keil uVision project RT-Thread.uvprojx, settings and files
target SWM190 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM190xB Synwit
  pack: Synwit.SWM32_DFP.2.0.8
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: RT-Thread
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c include: ..\..\SWM190_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM190_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM190_StdPeriph_Driver\CSL\SWM190_StdPeriph_Driver;.\APP;.\APP\rt-thread\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ./app/: main.c
    ./APP/: board.c
  group RT-Thread
    ./APP/rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group RT-Thread\port
    ./APP/rt-thread/libcpu/arm/cortex-m0/: cpuport.c context_rvds.S
  group CSL\StdPD
    ../../SWM190_StdPeriph_Driver/CSL/SWM190_StdPeriph_Driver/: SWM190_adc.c SWM190_exti.c SWM190_gpio.c SWM190_i2c.c SWM190_pwm.c SWM190_timr.c SWM190_uart.c SWM190_wdt.c SWM190_dma.c SWM190_flash.c SWM190_port.c SWM190_spi.c SWM190_rtc.c
  group CSL\CMSIS
    ../../SWM190_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM190.c
    ../../SWM190_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM190.s
