# Keil uVision project uCOS-II.uvprojx, settings and files
target SWM190 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM190xB Synwit
  pack: Synwit.SWM32_DFP.2.0.1
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: uCOS-II
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c include: ..\..\SWM190_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM190_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM190_StdPeriph_Driver\CSL\SWM190_StdPeriph_Driver;.\APP;.\APP\uCOS;.\APP\uCOS\Ports\ARMv6-M\ARM
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ./app/: main.c
  group uCOS
    ./APP/uCOS/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS\Port
    ./APP/uCOS/Ports/ARMv6-M/: os_cpu_c.c
    ./APP/uCOS/Ports/ARMv6-M/ARM/: os_cpu_a.asm
  group CSL\StdPD
    ../../SWM190_StdPeriph_Driver/CSL/SWM190_StdPeriph_Driver/: SWM190_adc.c SWM190_exti.c SWM190_gpio.c SWM190_i2c.c SWM190_pwm.c SWM190_timr.c SWM190_uart.c SWM190_wdt.c SWM190_dma.c SWM190_flash.c SWM190_port.c SWM190_spi.c SWM190_rtc.c
  group CSL\CMSIS
    ../../SWM190_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM190.c
    ../../SWM190_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM190.s
