# IAR project uCOS-II.ewp, settings and files
configuration SWM190 (ARM, debug)
  General.OGChipSelectEditMenu: SWM190xB Synwit SWM190xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\..\SWM190_StdPeriph_Driver\CSL\CMSIS\CoreSupport; ..\..\SWM190_StdPeriph_Driver\CSL\CMSIS\DeviceSupport; ..\..\SWM190_StdPeriph_Driver\CSL\SWM190_StdPeriph_Driver; .\APP; .\APP\uCOS; .\APP\uCOS\Ports\ARMv6-M\ARM
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _DLIB_FILE_DESCRIPTOR
  OBJCOPY.OOCOutputFile: uCOS-II.srec
  ILINK.IlinkOutputFile: uCOS-II.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ./app/: main.c
  group uCOS
    ./APP/uCOS/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS\Port
    ./APP/uCOS/Ports/ARMv6-M/: os_cpu_c.c
    ./APP/uCOS/Ports/ARMv6-M/IAR/: os_cpu_a.asm
  group CSL\StdPD
    ../../SWM190_StdPeriph_Driver/CSL/SWM190_StdPeriph_Driver/: SWM190_adc.c SWM190_exti.c SWM190_gpio.c SWM190_i2c.c SWM190_pwm.c SWM190_timr.c SWM190_uart.c SWM190_wdt.c SWM190_dma.c SWM190_flash.c SWM190_port.c SWM190_spi.c SWM190_rtc.c
  group CSL\CMSIS
    ../../SWM190_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM190.c
    ../../SWM190_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/iar/: startup_SWM190.s
